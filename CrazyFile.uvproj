# Keil uVision project CrazyFile.uvproj, settings and files
target CrazyFile (ARM-ADS)
  device: STM32F103CB STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: CrazyFile +hex
  c flags: Optim=1 OneElfS=1 uC99=1
  c define: USE_STDPERIPH_DRIVER,STM32F10X_MD
  c include: .\config;.\drivers\interface;.\hal\interface;.\modules\interface;.\platform;.\utils\interface;.\lib\CMSIS\Core\CM3;.\lib\CMSIS\Include;.\lib\FreeRTOS\include;.\lib\STM32F10x_StdPeriph_Driver\inc;.\lib\STM32_CPAL_Driver\inc;.\lib\STM32_CPAL_Driver\devices\stm32f10x;.\lib\STM32_USB_Device_Library\Core\src;.\lib\STM32_USB_OTG_Driver\inc;.\lib\FreeRTOS\portable\GCC\ARM_CM3
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group main
    ./init/: main.c
  group platform
    ./platform/cf2/: platform_cf2.c
  group modules
    ./modules/src/: comm.c commander.c console.c controller.c crtp.c crtpservice.c expbrd.c exptest.c info.c log.c mem.c neopixelring.c param.c pid.c pidctrl.c platformservice.c sensfusion6.c stabilizer.c system.c worker.c
  group utils
    ./utils/src/: filter.c cpuid.c cfassert.c configblockeeprom.c eprintf.c crc.c fp16.c debug.c abort.c configblockflash.c
  group hal
    ./hal/src/: eskylink.c freeRTOSdebug.c imu_cf1.c ledseq.c nrf24link.c pm_f103.c syslink.c
  group drivers
    ./drivers/src/: led.c exti.c nvic.c adc_f103.c hmc5883l.c i2cdev_f103.c motors_f103.c i2croutines.c mpu6050.c ms5611.c nrf24l01.c
  group CMSIS
    ./lib/CMSIS/Core/CM3/: core_cm3.c system_stm32f10x.c
    ./lib/CMSIS/Core/CM3/startup/arm/: startup_stm32f10x_md.s
  group FreeRTOS
    ./lib/FreeRTOS/: list.c queue.c tasks.c timers.c croutine.c
    ./lib/FreeRTOS/portable/MemMang/: heap_4.c
    ./lib/FreeRTOS/portable/GCC/ARM_CM3/: port.c
  group STM32F10x_StdPeriph_Driver
    ./lib/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
